<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\firmware_STM32L021K4Tx.ewp</path>
  </project>
  <batchBuild />
</workspace>
